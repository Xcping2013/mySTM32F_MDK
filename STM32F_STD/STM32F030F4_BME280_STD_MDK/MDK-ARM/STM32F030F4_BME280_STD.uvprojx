# Keil uVision project STM32F030F4_BME280_STD.uvprojx, settings and files
target MrSlate (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030F4_BME280_STD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\BME280_driver-master;..\STM32F0xx_StdPeriph_Driver\inc;..\User;..\BME280_driver-master;..\BME280_driver-master\selftest
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c delay.c stm32f0xx_it.c system_stm32f0xx.c startup_stm32f030.s
  group Drivers
    ../User/: IIC_Soft.c
    ../BME280_driver-master/: bme280.c
  group Libraries
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c
  group Test
    ../BME280_driver-master/selftest/: bme280_selftest.c
