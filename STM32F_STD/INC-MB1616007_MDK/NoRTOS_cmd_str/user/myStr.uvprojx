# Keil uVision project myStr.uvprojx, settings and files
target myStr (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MB1616007_B188&B235_fordebug +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\stm32f10x_Libraries;..\..\Libraries\stm32f10x_Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\myLib\peripherals;..\..\Libraries\myLib\Logic;..\systerm\delay;..\systerm\sys;..\systerm\usart;..\user;..\cmd;..\..\Libraries\myLib\flash;..\..\Libraries\myLib\eeprom;..\..\Libraries\myLib\dido
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group cmd
    ../cmd/: commands.c user_cmd_fun.c
  group Device
    ../../Libraries/myLib/Logic/: 74HC165.c 74HC595.c
    ../../Libraries/myLib/eeprom/: at24cxx.c
    ../../Libraries/myLib/dido/: dido.c
  group peripherals
    ../../Libraries/myLib/peripherals/: mcu_exit.c mcu_gpio.c mcu_softi2c.c mcu_wdg.c
  group sys
    ../systerm/delay/: delay.c
    ../systerm/sys/: sys.c
    ../systerm/usart/: usart.c
  group STM32F10X_FWLib
    ../../Libraries/stm32f10x_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_rcc.c
    ../../Libraries/stm32f10x_Libraries/: core_cm3.c startup_stm32f10x_hd.s
