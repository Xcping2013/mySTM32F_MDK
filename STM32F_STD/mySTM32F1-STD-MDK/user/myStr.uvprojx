# Keil uVision project myStr.uvprojx, settings and files
target myStr (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: INC-MBTMC429-02 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\stm32f10x_Libraries;..\Libraries\stm32f10x_Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\myLib\peripherals;..\systerm\delay;..\systerm\sys;..\systerm\usart;..\user;..\cmd;..\Libraries\myLib\eeprom;..\USMART;..\Libraries\myLib\motion;..\Libraries\myLib\bsp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group app/motor
    ../Libraries/myLib/motion/: motor_motion.c
  group app/debug
    ../cmd/: board_debug.c
  group app/tmc429
    ../Libraries/myLib/motion/: TMC429.c
  group app/eeprom
    ../Libraries/myLib/eeprom/: at24cxx.c
  group app/output
    ../Libraries/myLib/peripherals/: OUTPUT.c
  group app/input
    ../Libraries/myLib/peripherals/: INPUT.c
  group app/led
    ../Libraries/myLib/bsp/: led.c
  group app/USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group bsp/peripherals
    ../Libraries/myLib/peripherals/: mcu_gpio.c mcu_softi2c.c SPI.c exti.c tim.c
  group bsp/sys
    ../systerm/delay/: delay.c
    ../systerm/sys/: sys.c
    ../systerm/usart/: usart.c
  group STM32F10X_FWLib
    ../Libraries/stm32f10x_Libraries/: core_cm3.c startup_stm32f10x_hd.s
    ../Libraries/stm32f10x_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group readMe
    ../doc/: readme.txt PinSet.txt
